## arch/arm/hotplug/Kconfig
```kconfig
config HOTPLUG
 bool "Cpu hotplug driver"
 default y
 help
 cpu hotplug driver for ARM SOCs
```
